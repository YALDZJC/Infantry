<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Infantry_Wheels_Gimbal_F407_2024630.ewp</path>
  </project>
  <batchBuild />
</workspace>
